SRC_URI = "${MISC_GIT_URI}/${MISC_GIT_PREFIX}${BPN}.git;protocol=${MISC_GIT_PROTOCOL} \
           file://gnu-configize.in \
          "
