SRC_URI = "${NONDEBIAN_GIT_URI}/${BPN}.git;protocol=${NONDEBIAN_GIT_PROTOCOL} \
           file://gnu-configize.in"
