require gcc-cross_${PV}.bb
require recipes-devtools/gcc/gcc-cross-initial.inc
