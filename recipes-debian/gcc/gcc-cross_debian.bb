require gcc-4.9.inc
require recipes-devtools/gcc/gcc-cross.inc
require gcc-shared-source.inc
