require markupsafe.inc
PR = "${INC_PR}.0"

inherit python3native
DEPENDS += "python3-setuptools-native"
