SUMMARY = "a tool that creates a shadow directory of symbolic links to another directory tree"

require xorg-util-common.inc

PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=28f22421a52f2e70ef04c9ce398fa28e"

DEPENDS = "util-macros xproto"
