require u-boot-common.inc
require recipes-bsp/u-boot/u-boot.inc
