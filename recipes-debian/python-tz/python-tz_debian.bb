require python-tz.inc

PR = "${INC_PR}.0"
DEPENDS += "python-setuptools-native"
