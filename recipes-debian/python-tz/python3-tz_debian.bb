require python-tz.inc

PR = "${INC_PR}.1"
DEPENDS += "python3-setuptools-native"
