require python-cffi.inc

inherit setuptools3
