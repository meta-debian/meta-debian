require recipes-gnome/gnome/gnome-common_3.7.4.bb

inherit debian-package
DEBIAN_SECTION = "gnome"

DPR = "0"

LICENSE="GPLv2"
LIC_FILES_CHKSUM="file://COPYING;md5=b234ee4d69f5fce4486a80fdaf4a4263"
