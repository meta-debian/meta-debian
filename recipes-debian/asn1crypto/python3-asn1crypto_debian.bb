require asn1crypto.inc

inherit setuptools3
