require pyasn1.inc

inherit setuptools3
