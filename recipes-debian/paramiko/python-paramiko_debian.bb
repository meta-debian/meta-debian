require paramiko.inc

inherit setuptools
