require paramiko.inc

inherit setuptools3
