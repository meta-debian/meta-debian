FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://runtest-setup-resolve-conf.patch"

