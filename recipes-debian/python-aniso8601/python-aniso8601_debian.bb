require python-aniso8601.inc

PR = "${INC_PR}.1"
DEPENDS += "python-setuptools-native"
