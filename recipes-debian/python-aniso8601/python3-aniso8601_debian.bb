require python-aniso8601.inc
PR = "${INC_PR}.1"

inherit python3native
DEPENDS += "python3-setuptools-native"
