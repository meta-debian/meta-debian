DEPENDS_remove = "gtk-doc-stub-native"
