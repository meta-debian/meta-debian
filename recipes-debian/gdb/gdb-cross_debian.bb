require recipes-devtools/gdb/gdb-cross.inc
require gdb-8.2.1.inc
