require ply.inc

inherit setuptools
