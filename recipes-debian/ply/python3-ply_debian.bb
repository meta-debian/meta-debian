require ply.inc

inherit setuptools3
