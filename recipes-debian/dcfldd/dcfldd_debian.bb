# base recipe: not base recipe
# base branch: 

LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://COPYING;md5=94d55d512a9ba36caa9b7df079bae19f"

PR = "r0"
inherit debian-package
PV = "1.3.4.1"

inherit autotools
