DESCRIPTION = "lcab is a small program for Linux that creates a cabinet (.cab) \
               archive from a set of input files \
               "

LICENSE = "GPL-2.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=393a5ca445f6965873eca0259a17f833"

PR = "r0"

inherit debian-package autotools
PV = "1.0b12"

