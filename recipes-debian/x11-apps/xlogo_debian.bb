require x11-apps.inc

DESCRIPTION = "a demo program that displays the X logo"

LIC_FILES_CHKSUM = "file://COPYING;md5=c9365edf14143acf04c08b386ff7e2a4"

S = "${DEBIAN_UNPACK_DIR}/xlogo"
