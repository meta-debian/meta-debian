require x11-apps.inc

DESCRIPTION = "a demo program animating polyhedrons"

LIC_FILES_CHKSUM = "file://COPYING;md5=83340fc8e3d8d0c4d23a4c62f6dd83a9"

S = "${DEBIAN_UNPACK_DIR}/ico"
