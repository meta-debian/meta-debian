require x11-apps.inc

DESCRIPTION = "a tool for creating X cursor files from PNGs"

LIC_FILES_CHKSUM = "file://COPYING;md5=bd1fb9ee90eead85f7b171807b3ab4f2"

S = "${DEBIAN_UNPACK_DIR}/xcursorgen"
