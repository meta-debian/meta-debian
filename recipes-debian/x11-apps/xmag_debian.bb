require x11-apps.inc

DESCRIPTION = "magnifies parts of the X screen"

LIC_FILES_CHKSUM = "file://COPYING;md5=3413fe6832380b44b69b172d2d1b2387"

S = "${DEBIAN_UNPACK_DIR}/xmag"
