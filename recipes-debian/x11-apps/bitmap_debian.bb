require x11-apps.inc

DESCRIPTION = "tools for manipulating bitmap images"

LIC_FILES_CHKSUM = "file://COPYING;md5=7966819d85ef9e09892d9161ce376270"

S = "${DEBIAN_UNPACK_DIR}/bitmap"
