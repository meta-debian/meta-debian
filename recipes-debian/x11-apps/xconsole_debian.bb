require x11-apps.inc

DESCRIPTION = "monitors system console messages"

LIC_FILES_CHKSUM = "file://COPYING;md5=3ae977a68975db2fb36e2e77081085bb"

S = "${DEBIAN_UNPACK_DIR}/xconsole"
