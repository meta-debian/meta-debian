require x11-apps.inc

DESCRIPTION = "a tool to set opacity property on a window"

LIC_FILES_CHKSUM = "file://COPYING;md5=2e56d5276d899b8afe6edd855ec6708b"

S = "${DEBIAN_UNPACK_DIR}/transset"
