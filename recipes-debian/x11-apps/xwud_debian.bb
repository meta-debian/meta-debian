require x11-apps.inc

DESCRIPTION = "a viewer for window dumps created by xwd"

LIC_FILES_CHKSUM = "file://COPYING;md5=31e8892c80b7a0c1c5f37c8e8ae6d794"

S = "${DEBIAN_UNPACK_DIR}/xwud"
