require x11-apps.inc

DESCRIPTION = "a program to test render extension implementations"

LIC_FILES_CHKSUM = "file://COPYING;md5=0672108af794b575233e866a20cb267d"

S = "${DEBIAN_UNPACK_DIR}/rendercheck"
