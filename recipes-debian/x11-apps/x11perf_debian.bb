require x11-apps.inc

DESCRIPTION = "tools for benchmarking graphical operations under the X Window System"

LIC_FILES_CHKSUM = "file://COPYING;md5=428ca4d67a41fcd4fc3283dce9bbda7e"

S = "${DEBIAN_UNPACK_DIR}/x11perf"
