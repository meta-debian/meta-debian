require x11-apps.inc

DESCRIPTION = "a graphics demo"

LIC_FILES_CHKSUM = "file://COPYING;md5=78683538599762c70b92efd4b0a4cba7"

S = "${DEBIAN_UNPACK_DIR}/xgc"
