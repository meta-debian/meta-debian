require x11-apps.inc

DESCRIPTION = "graphical clocks"

LIC_FILES_CHKSUM = "file://COPYING;md5=43d419f7e7b7120f99d2d50739b7c5eb"

S = "${DEBIAN_UNPACK_DIR}/oclock"
