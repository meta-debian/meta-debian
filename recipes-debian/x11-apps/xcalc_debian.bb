require x11-apps.inc

DESCRIPTION = "a scientific calculator desktop accessory"

LIC_FILES_CHKSUM = "file://COPYING;md5=1cc25ece7aa5c54ca7fd23b1c9111c23"

S = "${DEBIAN_UNPACK_DIR}/xcalc"
