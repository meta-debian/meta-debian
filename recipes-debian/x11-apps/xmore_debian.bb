require x11-apps.inc

DESCRIPTION = "a text pager"

LIC_FILES_CHKSUM = "file://COPYING;md5=4641deddaa80fe7ca88e944e1fd94a94"

S = "${DEBIAN_UNPACK_DIR}/xmore"
