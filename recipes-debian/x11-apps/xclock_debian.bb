require x11-apps.inc

DESCRIPTION = "graphical clocks"

LIC_FILES_CHKSUM = "file://COPYING;md5=857759ade8f2ddde5c7b32ef7356ea36"

S = "${DEBIAN_UNPACK_DIR}/xclock"
