require x11-apps.inc

DESCRIPTION = "a viewer for ditroff output"

LIC_FILES_CHKSUM = "file://COPYING;md5=e9902d8242e75ce1640bfd8bfaa4d561"

S = "${DEBIAN_UNPACK_DIR}/xditview"
