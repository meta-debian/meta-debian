require x11-apps.inc

DESCRIPTION = "a tool which tells you when you have new email"

LIC_FILES_CHKSUM = "file://COPYING;md5=a4f198e2c1835cf956f36b5958ab99e7"

S = "${DEBIAN_UNPACK_DIR}/xbiff"
