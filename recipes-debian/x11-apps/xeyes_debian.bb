require x11-apps.inc

DESCRIPTION = "a demo program in which a pair of eyes track the pointer"

LIC_FILES_CHKSUM = "file://COPYING;md5=3ea51b365051ac32d1813a7dbaa4bfc6"

S = "${DEBIAN_UNPACK_DIR}/xeyes"
