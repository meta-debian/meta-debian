require x11-apps.inc

DESCRIPTION = "a utility for taking window dumps ("screenshots") of the X session"

LIC_FILES_CHKSUM = "file://COPYING;md5=c0cdb783e9a0198237371fdaa26a18bf"

S = "${DEBIAN_UNPACK_DIR}/xwd"
