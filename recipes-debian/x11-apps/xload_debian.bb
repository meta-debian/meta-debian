require x11-apps.inc

DESCRIPTION = "a monitor for the system load average"

LIC_FILES_CHKSUM = "file://COPYING;md5=95a73d76a420c774909b0df8cd45cbe3"

S = "${DEBIAN_UNPACK_DIR}/xload"
