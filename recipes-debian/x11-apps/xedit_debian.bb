require x11-apps.inc

DESCRIPTION = "a simple text editor for X"

LIC_FILES_CHKSUM = "file://COPYING;md5=ee971579412993d428c07eef9d8ea585"

S = "${DEBIAN_UNPACK_DIR}/xedit"
