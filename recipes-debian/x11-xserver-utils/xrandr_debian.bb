require x11-xserver-utils.inc

DESCRIPTION = "a command-line interface to the RandR extension"

LIC_FILES_CHKSUM = "file://COPYING;md5=fe1608bdb33cf8c62a4438f7d34679b3"

S = "${DEBIAN_UNPACK_DIR}/xrandr"
