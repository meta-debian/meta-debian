require x11-xserver-utils.inc

DESCRIPTION = "a tool for setting miscellaneous X server parameters"

LIC_FILES_CHKSUM = "file://COPYING;md5=bea81cc9827cdf1af0e12c2b8228cf8d"

S = "${DEBIAN_UNPACK_DIR}/xset"
