require x11-xserver-utils.inc

DESCRIPTION = "a tool that forces a redraw of the X screen"

LIC_FILES_CHKSUM = "file://COPYING;md5=dad633bce9c3cd0e3abf72a16e0057cf"

S = "${DEBIAN_UNPACK_DIR}/xrefresh"
