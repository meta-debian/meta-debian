require x11-xserver-utils.inc

DESCRIPTION = "a utility to selectively define standard colormap properties"

LIC_FILES_CHKSUM = "file://COPYING;md5=2b08d9e2e718ac83e6fe2b974d4b5fd8"

S = "${DEBIAN_UNPACK_DIR}/xstdcmap"
