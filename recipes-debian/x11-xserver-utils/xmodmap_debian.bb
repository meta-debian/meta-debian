require x11-xserver-utils.inc

DESCRIPTION = "a utility for modifying keymaps and pointer button mappings in X"

LIC_FILES_CHKSUM = "file://COPYING;md5=272c17e96370e1e74773fa22d9989621"

S = "${DEBIAN_UNPACK_DIR}/xmodmap"
