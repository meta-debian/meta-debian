require x11-xserver-utils.inc

DESCRIPTION = "a tool for customizing X server modelines for your monitor"

LIC_FILES_CHKSUM = "file://COPYING;md5=fa0b9c462d8f2f13eba26492d42ea63d"

S = "${DEBIAN_UNPACK_DIR}/xvidtune"
