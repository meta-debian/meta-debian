require x11-xserver-utils.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=ef598adbe241bd0b0b9113831f6e249a"

S = "${DEBIAN_UNPACK_DIR}/rgb"
