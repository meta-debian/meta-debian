require x11-xserver-utils.inc

DESCRIPTION = "a simple program for managing utmp/wtmp entries"

LIC_FILES_CHKSUM = "file://COPYING;md5=d938a70c8280c265a1ccd2954365d185"

S = "${DEBIAN_UNPACK_DIR}/sessreg"
