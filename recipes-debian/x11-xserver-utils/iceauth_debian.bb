require x11-xserver-utils.inc

DESCRIPTION = "a tool for manipulating ICE protocol authorization records"

LIC_FILES_CHKSUM = "file://COPYING;md5=13f70acf3c27f5f834bbc954df775f8e"

S = "${DEBIAN_UNPACK_DIR}/iceauth"
