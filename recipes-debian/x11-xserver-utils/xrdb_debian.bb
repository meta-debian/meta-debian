require x11-xserver-utils.inc

DESCRIPTION = "a tool to manage the X server resource database"

LIC_FILES_CHKSUM = "file://COPYING;md5=d1167c4f586bd41f0c62166db4384a69"

S = "${DEBIAN_UNPACK_DIR}/xrdb"
