require x11-xserver-utils.inc

DESCRIPTION = "tools for handling X Input devices"

LIC_FILES_CHKSUM = "file://COPYING;md5=9b37e00e7793b667cbc64f9df7b6d733"

S = "${DEBIAN_UNPACK_DIR}/xsetmode"
