require x11-xserver-utils.inc

DESCRIPTION = "a very dangerous program that you should never use"

LIC_FILES_CHKSUM = "file://COPYING;md5=8fbed71dddf48541818cef8079124199"

S = "${DEBIAN_UNPACK_DIR}/xhost"
