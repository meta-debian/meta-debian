require x11-xserver-utils.inc

DESCRIPTION = "a device color characteristic utility for the X Color Management System"

LIC_FILES_CHKSUM = "file://COPYING;md5=2f6f723cc96a47799cdc2427abd3ce28"

S = "${DEBIAN_UNPACK_DIR}/xcmsdb"
