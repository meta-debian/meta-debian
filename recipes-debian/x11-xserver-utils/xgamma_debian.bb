require x11-xserver-utils.inc

DESCRIPTION = "a tool for querying and setting a monitor's gamma correction"

LIC_FILES_CHKSUM = "file://COPYING;md5=ac9801b8423fd7a7699ccbd45cf134d8"

S = "${DEBIAN_UNPACK_DIR}/xgamma"
