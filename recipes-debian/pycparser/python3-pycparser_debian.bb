require pycparser.inc

inherit setuptools3
