require pycparser.inc

inherit setuptools
