require python-nacl.inc

inherit setuptools3
