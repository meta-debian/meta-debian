require python-nacl.inc

inherit setuptools
