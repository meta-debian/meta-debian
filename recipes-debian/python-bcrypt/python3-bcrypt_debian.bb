require python-bcrypt.inc

inherit setuptools3
