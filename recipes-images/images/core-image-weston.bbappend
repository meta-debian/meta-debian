require core-image-weston.inc
