require recipes-graphics/images/core-image-weston.bb
require core-image-sdk.inc

