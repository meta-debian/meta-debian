require recipes-core/images/core-image-minimal.bb
require core-image-sdk.inc

