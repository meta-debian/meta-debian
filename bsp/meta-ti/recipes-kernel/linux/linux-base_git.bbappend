LINUX_DEFCONFIG_beaglebone = "omap2plus_defconfig"

KERNEL_EXTRA_ARGS += "LOADADDR=${UBOOT_ENTRYPOINT}"
