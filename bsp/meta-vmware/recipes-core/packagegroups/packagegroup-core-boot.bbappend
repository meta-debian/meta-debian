# required for grub based legacy boot
RDEPENDS_${PN} += "kernel-image \
                   kernel-modules \
                   grub2 \
                   "
