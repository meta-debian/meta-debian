# Add swupdate to the image
RDEPENDS_${PN} += "\
    swupdate \
    swupdate-www \
    "
