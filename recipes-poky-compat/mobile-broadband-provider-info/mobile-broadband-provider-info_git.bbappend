SRC_URI_remove = " \
    git://gitlab.gnome.org/GNOME/mobile-broadband-provider-info.git;protocol=https \
"
SRC_URI_prepend = " \
    git://gitlab.gnome.org/GNOME/mobile-broadband-provider-info.git;protocol=https;branch=main \
"
