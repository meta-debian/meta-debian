# Exclude some unnecessary packages
RDEPENDS_${PN}_remove = "\
nativesdk-unfs3 \
nativesdk-smartpm \
"
