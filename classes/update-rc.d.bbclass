#
# Override meta/classes/update-rc.d.bbclass because update-rc.d 
# is no need on current system.
#
