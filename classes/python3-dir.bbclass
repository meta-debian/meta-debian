PYTHON_BASEVERSION = "3.4"
PYTHON_ABI = "m"
PYTHON_DIR = "python${PYTHON_BASEVERSION}"
PYTHON_PN = "python3"
PYTHON_SITEPACKAGES_DIR = "${nonarch_libdir}/${PYTHON_PN}/dist-packages"
