#
# Override meta/classes/gtk-doc.bbclass to not depend on gtk-doc package
#
